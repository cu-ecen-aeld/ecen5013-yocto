IMAGE_INSTALL:append = " bash"
inherit core-image
